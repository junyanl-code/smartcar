# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\..\StdPeriph_Driver\inc;..\..\StartUp;..\..\CMSIS;..\LED;..\SYSTICK;..\USART;..\BUZZER;..\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group CMSIS
    ../../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group StdPeriph_Driver
    ../../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ../../StartUp/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group LED
    ../LED/: led.c
  group SYSTICK
    ../SYSTICK/: systick.c
  group USART
    ../USART/: usart.c
  group BUZZER
    ../BUZZER/: buzzer.c
  group PWM
    ../PWM/: pwm.c
